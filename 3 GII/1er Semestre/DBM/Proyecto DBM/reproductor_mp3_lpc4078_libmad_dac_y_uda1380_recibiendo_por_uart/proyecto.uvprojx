# Keil uVision project proyecto.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC4078FBD80 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proyecto
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;.\libmad
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: dac_lpc40xx.c error.c gpio_lpc40xx.c i2c_lpc40xx.c iocon_lpc40xx.c main.c reproductor_mp3.c timer_lpc40xx.c generacion_audio_con_uda1380.c uda1380_lpc4078fbd80.c uart_lpc40xx_xon_xoff.c lcd_hd44780_lpc40xx.c lcd_hd44780_lpc40xx.h retardo_software.c retardo_software_asm.s
  group libmad
    ./libmad/: bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c stream.c synth.c timer.c imdct_l_arm.S
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
